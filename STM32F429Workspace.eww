<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Projects\Blinky\Blinky.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Projects\freqmeter\freqmeter.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Projects\task7\task7.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Projects\Timer\Timer.ewp</path>
    </project>
    <batchBuild />
</workspace>
